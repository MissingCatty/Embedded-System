# Keil uVision project Project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\Start;.\Library;.\User;.\FreeRTOS_Inc;.\FreeRTOS_Port\RVDS\ARM_CM3;.\System;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c system_stm32f10x.c
  group User
    ./User/: main.c stm32f10x_it.c Experiment.c
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS_CORE
    ./FreeRTOS_Core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS_Port/MemMang/: heap_4.c
    ./FreeRTOS_Port/RVDS/ARM_CM3/: port.c
  group System
    ./System/: Delay.c Timer.h Timer.c
  group Hardware
    ./Hardware/: LightSensor.h LightSensor.c LED.h LED.c OLED.c OLED.h OLED_Font.h ADC.c ADC.h DMA.c DMA.h Key.c Key.h USART.c USART.h I2C.c I2C.h SPI.c SPI.h MPU6050.c MPU6050.h MPU6050_Reg.h
