# Keil uVision project FreeRTOS.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC5)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE
  c include: .\Firmware\CMSIS\Core;.\Firmware\CMSIS\Device;.\Firmware\Driver\inc;.\APP;.\Driver;.\Lib\FreeRTOS\include;.\Lib\FreeRTOS\portable\RVDS\ARM_CM4F;.\Lib\LVGL;.\APP\tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ./APP/: main.c jobs.c
    ./APP/tasks/: foreground.c background.c app.c
  group APP/override
    ./APP/override/: _printf.c
  group Driver
    ./Driver/led/: led.c
    ./Driver/usart/: usart.c ringbuffer8.c
    ./Driver/timer/: timer.c
    ./Driver/dht11/: dht11.c
    ./Driver/esp/: esp_at.c
    ./Driver/rtc/: rtc.c
    ./Driver/ili9341/: lvgl_ili9341.c
    ./Driver/lcd/: lcd.c
  group Resource/converted_img
    ./Resource/converted_img/3d_60/: wifi_on.c wifi_off.c weather_cloud.c weather_na.c weather_nosun.c weather_rain.c weather_snow.c weather_sun.c weather_thounderrain.c thermometer.c
  group Firmware
    ./Firmware/CMSIS/Device/: startup_stm32f40xx.s stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_conf.h
    ./Firmware/Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Lib/freertos/core
    ./Lib/FreeRTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Lib/freertos/portable
    ./Lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./Lib/FreeRTOS/portable/MemMang/: heap_4.c
  group Lib/lvgl
    ./Lib/LVGL/: lv_conf.h lv_version.h lvgl.h lvgl_private.h
  group Lib/lvgl/src
    ./Lib/LVGL/src/: lv_init.c
    ./Lib/LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ./Lib/LVGL/src/display/: lv_display.c
    ./Lib/LVGL/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ./Lib/LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ./Lib/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ./Lib/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ./Lib/LVGL/src/drivers/display/ili9341/: lv_ili9341.c
    ./Lib/LVGL/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ./Lib/LVGL/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./Lib/LVGL/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ./Lib/LVGL/src/layouts/: lv_layout.c
    ./Lib/LVGL/src/layouts/flex/: lv_flex.c
    ./Lib/LVGL/src/layouts/grid/: lv_grid.c
    ./Lib/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ./Lib/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_assert.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ./Lib/LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ./Lib/LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ./Lib/LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ./Lib/LVGL/src/osal/: lv_freertos.c lv_os.c lv_os_none.c
    ./Lib/LVGL/src/stdlib/: lv_mem.c
    ./Lib/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ./Lib/LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ./Lib/LVGL/src/themes/: lv_theme.c
    ./Lib/LVGL/src/themes/default/: lv_theme_default.c
    ./Lib/LVGL/src/themes/mono/: lv_theme_mono.c
    ./Lib/LVGL/src/themes/simple/: lv_theme_simple.c
    ./Lib/LVGL/src/tick/: lv_tick.c
    ./Lib/LVGL/src/others/observer/: lv_observer.c
    ./Lib/LVGL/src/others/sysmon/: lv_sysmon.c
  group Lib/lvgl/widgets
    ./Lib/LVGL/src/widgets/label/: lv_label.c
    ./Lib/LVGL/src/widgets/arc/: lv_arc.c
    ./Lib/LVGL/src/widgets/arclabel/: lv_arclabel.c
    ./Lib/LVGL/src/widgets/image/: lv_image.c
